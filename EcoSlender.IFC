Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EcoSlender.IFC
Time: 2022-01-04T06:08:17
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EcoSlender¥~´ß01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EcoSlender¥~´ß©T©w¤ù01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
